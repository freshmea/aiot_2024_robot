Commit message: aa

File: aiot_ws/src/move_turtle/urdf/materials.urdf (robot description, URDF)
Before this commit: robot myfirst, 3 links, 2 joints
Joints:
- joint base_to_left_leg: child right_leg -> left_leg
